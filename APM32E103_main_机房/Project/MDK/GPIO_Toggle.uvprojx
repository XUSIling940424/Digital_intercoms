# Keil uVision project GPIO_Toggle.uvprojx, settings and files
target APM32E103_MINI (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: APM32E103ZE Geehy
  pack: Geehy.APM32E1xx_DFP.1.0.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: GPIO_Toggle
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: APM32E10X_HD,APM32E103_MINI
  c include: ..\..\Include;..\..\Boards;..\..\Libraries\APM32E10x_StdPeriphDriver\inc;..\..\Libraries\CMSIS\Include;..\..\Libraries\Device\Geehy\APM32E10x\Include;..\..\Boards\Board_APM32E103_MINI\src;..\..\Boards\Board_APM32E103_MINI\inc;..\..\BSP\Can;..\..\BSP\Gpio;..\..\BSP\Time;..\..\BSP\Usart;..\..\APP\My_Can;..\..\APP\My_Misc;..\..\APP\MY_Time;..\..\APP\My_Usart
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application
    ../../Source/: apm32e10x_int.c main.c
  group CMSIS
    ../../Source/: system_apm32e10x.c
    ../../Libraries/Device/Geehy/APM32E10x/Source/arm/: startup_apm32e10x_hd.s
  group StdPeriphDriver
    ../../Libraries/APM32E10x_StdPeriphDriver/src/: apm32e10x_adc.c apm32e10x_bakpr.c apm32e10x_can.c apm32e10x_crc.c apm32e10x_dac.c apm32e10x_dbgmcu.c apm32e10x_dma.c apm32e10x_dmc.c apm32e10x_eint.c apm32e10x_fmc.c apm32e10x_gpio.c apm32e10x_i2c.c apm32e10x_iwdt.c apm32e10x_misc.c apm32e10x_pmu.c apm32e10x_rcm.c apm32e10x_rtc.c apm32e10x_sci2c.c apm32e10x_sdio.c apm32e10x_smc.c apm32e10x_spi.c apm32e10x_tmr.c apm32e10x_usart.c apm32e10x_usb.c apm32e10x_wwdt.c
  group Board
    ../../Boards/: Board.c
  group APP
    ../../APP/My_Can/: My_Can.c
    ../../APP/My_Misc/: my_misc.c
    ../../APP/MY_Time/: my_time.c
    ../../APP/My_Usart/: My_Usart.c
  group BSP
    ../../BSP/Can/: Can.c
    ../../BSP/Usart/: Usart.c
    ../../BSP/Gpio/: gpio.c
    ../../BSP/Time/: Time.c
software components: RTOS:kernel 3.1.5
