# Keil uVision project GPIO_Toggle.uvprojx, settings and files
target Digital_intercom (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: APM32F103C8 Geehy
  pack: Geehy.APM32F1xx_DFP.1.0.9
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: GPIO_Toggle +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: APM32F10X_HD,APM32F103_MINI
  c include: ..\..\Include;..\..\Boards;..\..\Libraries\APM32F10x_StdPeriphDriver\inc;..\..\Libraries\CMSIS\Include;..\..\Libraries\Device\Geehy\APM32F10x\Include;..\..\BSP\Can;..\..\BSP\Usart;..\..\APP\My_Can;..\..\APP\My_Usart;..\..\APP\My_Misc;..\..\BSP\Gpio;..\..\BSP\Time;..\..\APP\MY_Time;..\..\W5500;..\..\Net_App\DHCP;..\..\BSP\Spi;..\..\Net_App\TCP_Client;..\..\Net_App\TCP_Server;..\..\Net_App\UDP;..\..\Net_App\My_Net
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ../../Source/: system_apm32f10x.c
    ../../Libraries/Device/Geehy/APM32F10x/Source/arm/: startup_apm32f10x_hd.s
  group StdPeriphDriver
    ../../Libraries/APM32F10x_StdPeriphDriver/src/: apm32f10x_adc.c apm32f10x_bakpr.c apm32f10x_can.c apm32f10x_crc.c apm32f10x_dac.c apm32f10x_dbgmcu.c apm32f10x_dma.c apm32f10x_dmc.c apm32f10x_eint.c apm32f10x_fmc.c apm32f10x_gpio.c apm32f10x_i2c.c apm32f10x_iwdt.c apm32f10x_misc.c apm32f10x_pmu.c apm32f10x_qspi.c apm32f10x_rcm.c apm32f10x_rtc.c apm32f10x_sci2c.c apm32f10x_sdio.c apm32f10x_smc.c apm32f10x_spi.c apm32f10x_tmr.c apm32f10x_usart.c apm32f10x_wwdt.c
  group Application
    ../../Source/: main.c apm32f10x_int.c
  group Board
    ../../Boards/: Board.c
  group BSP
    ../../BSP/Can/: Can.c
    ../../BSP/Usart/: Usart.c
    ../../BSP/Gpio/: gpio.c
    ../../BSP/Time/: Time.c
    ../../BSP/Spi/: Spi.c
  group APP
    ../../APP/My_Can/: My_Can.c
    ../../APP/My_Usart/: My_Usart.c
    ../../APP/My_Misc/: my_misc.c
    ../../APP/MY_Time/: my_time.c
  group W550
    ../../W5500/: socket.c utility.c w5500.c w5500_conf.c
  group Net_App
    ../../Net_App/DHCP/: dhcp.c
    ../../Net_App/TCP_Client/: tcp_client.c
    ../../Net_App/TCP_Server/: tcp_server.c
    ../../Net_App/UDP/: udp.c
    ../../Net_App/My_Net/: my_netapp.c
software components: RTOS:kernel 3.1.5
